# Keil uVision project LCD.uvprojx, settings and files
target LCD (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\1.44TFT;..\HARDWARE\US100;..\HARDWARE\HC04;..\HARDWARE\TIME;..\HARDWARE\WIFI;..\HARDWARE\PWM;..\HARDWARE\WHEEL;..\HARDWARE\LOCATION;..\HARDWARE\KEY;..\HARDWARE\PAWS;..\HARDWARE\PID;..\HARDWARE\Choise
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c data_type.c user_main.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/1.44TFT/: GUI.c Lcd_Driver.c TFT_demo.c
    ../HARDWARE/US100/: us100.c
    ../HARDWARE/HC04/: hc04.c
    ../HARDWARE/TIME/: timer.c
    ../HARDWARE/WIFI/: wifi.c wifi_base.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/WHEEL/: wheel.c
    ../HARDWARE/LOCATION/: location.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/PAWS/: paws.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/Choise/: Choise.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c
  group README
    ../: readme.txt
